# Keil uVision project bootloader.uvprojx, settings and files
target bootloader (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: -AT32F415RBT7 ArteryTek
  pack: ArteryTek.AT32F415_DFP.2.1.6
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: bootloader +hex
  AfterMake: fromelf.exe --bin --output .\Listings\@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 v6Lto=1 wLevel=2
  c define: AT32F415RBT7,USE_STDPERIPH_DRIVER,AT_START_F415_V1
  c include: ..\libraries\drivers\inc;..\libraries\cmsis\cm4\core_support;..\libraries\cmsis\cm4\device_support;..\inc;..\at32f415_board
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../src/: at32f415_clock.c at32f415_int.c flash.c iap.c usart.c tmr.c main.c wk_crc.c
  group bsp
    ../at32f415_board/: at32f415_board.c
  group firmware
    ../libraries/drivers/src/: at32f415_crm.c at32f415_flash.c at32f415_gpio.c at32f415_usart.c at32f415_tmr.c at32f415_misc.c at32f415_crc.c
  group cmsis
    ../libraries/cmsis/cm4/device_support/: system_at32f415.c
    ../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f415.s
  group readme
    ../: readme.txt

# Keil uVision project AT32F415RBT7_WorkBench.uvprojx, settings and files
target AT32F415RBT7_WorkBench (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: -AT32F415RBT7 ArteryTek
  pack: ArteryTek.AT32F415_DFP.2.1.6
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: AT32F415RBT7_WorkBench +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F415RBT7,USE_STDPERIPH_DRIVER
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../src/: main.c at32f415_wk_config.c at32f415_int.c wk_system.c wk_crc.c wk_debug.c wk_usart.c iap.c flash.c
  group firmware
    ../../libraries/drivers/src/: at32f415_crc.c at32f415_crm.c at32f415_debug.c at32f415_flash.c at32f415_gpio.c at32f415_misc.c at32f415_pwc.c at32f415_usart.c
  group cmsis
    ../../libraries/cmsis/cm4/device_support/: system_at32f415.c
    ./: startup_at32f415.s
